<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\self_define_controller_G030FINAL.ewp</path>
  </project>
  <batchBuild />
</workspace>
